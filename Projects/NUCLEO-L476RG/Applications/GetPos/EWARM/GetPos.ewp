# IAR project GetPos.ewp, settings and files
configuration GetPos (ARM, debug)
  General.OGChipSelectEditMenu: STM32L476RG ST STM32L476RG
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32L476xx
  ICCARM.CCIncludePath2: ../Core/Inc; ../../../../../Drivers/STM32L4xx_HAL_Driver/Inc; ../../../../../Drivers/STM32L4xx_HAL_Driver/Inc/Legacy; ../../../../../Middlewares/Third_Party/FreeRTOS/Source/include; ../../../../../Middlewares/Third_Party/FreeRTOS/Source/portable/IAR/ARM_CM4F; ../../../../../Drivers/CMSIS/Device/ST/STM32L4xx/Include; ../../../../../Drivers/CMSIS/Include; ../GNSS/App; ../GNSS/Target; ../../../../../Middlewares/ST/lib_gnss/LibGNSS/Inc; ../../../../../Middlewares/ST/lib_gnss/LibNMEA/Inc; ../../../../../Drivers/BSP/Components/teseo_liv3f; ../../../../../Drivers/BSP/GNSS1A1; ../../../../../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ../Core/Inc; ../GNSS/App; ../GNSS/Target; ../../../../../Drivers/STM32L4xx_HAL_Driver/Inc; ../../../../../Drivers/STM32L4xx_HAL_Driver/Inc/Legacy; ../../../../../Middlewares/Third_Party/FreeRTOS/Source/include; ../../../../../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2; ../../../../../Middlewares/Third_Party/FreeRTOS/Source/portable/IAR/ARM_CM4F; ../../../../../Drivers/CMSIS/Device/ST/STM32L4xx/Include; ../../../../../Drivers/CMSIS/Include; ../../../../../Middlewares/ST/lib_gnss/LibGNSS/Inc; ../../../../../Middlewares/ST/lib_gnss/LibNMEA/Inc; ../../../../../Drivers/BSP/Components/teseo_liv3f; ../../../../../Drivers/BSP/GNSS1A1
  OBJCOPY.OOCOutputFile: GetPos.hex
  ILINK.IlinkOutputFile: GetPos.out
  ILINK.IlinkIcfFile: stm32l476xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ./: startup_stm32l476xx.s
  group Application/User/Core
    ../Core/Src/: main.c freertos.c stm32l4xx_nucleo_bus.c stm32l4xx_nucleo.c stm32l4xx_it.c stm32l4xx_hal_msp.c stm32l4xx_hal_timebase_tim.c
  group Application/User/GNSS/App
    ../GNSS/App/: gnss_utils.c app_gnss.c
  group Application/User/GNSS/Target
    ../GNSS/Target/: stm32_bus_ex.c gnss_lib_config.c
  group Drivers/BSP/Components
    ../../../../../Drivers/BSP/Components/teseo_liv3f/: teseo_liv3f.c teseo_liv3f_i2c.c teseo_liv3f_queue.c teseo_liv3f_uart.c
  group Drivers/BSP/GNSS1A1
    ../../../../../Drivers/BSP/GNSS1A1/: gnss1a1_gnss.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32l4xx.c
  group Drivers/STM32L4xx_HAL_Driver
    ../../../../../Drivers/STM32L4xx_HAL_Driver/Src/: stm32l4xx_hal_tim.c stm32l4xx_hal_tim_ex.c stm32l4xx_hal_i2c.c stm32l4xx_hal_i2c_ex.c stm32l4xx_hal.c stm32l4xx_hal_rcc.c stm32l4xx_hal_rcc_ex.c stm32l4xx_hal_flash.c stm32l4xx_hal_flash_ex.c stm32l4xx_hal_flash_ramfunc.c stm32l4xx_hal_gpio.c stm32l4xx_hal_dma.c stm32l4xx_hal_dma_ex.c stm32l4xx_hal_pwr.c stm32l4xx_hal_pwr_ex.c stm32l4xx_hal_cortex.c stm32l4xx_hal_exti.c stm32l4xx_hal_uart.c stm32l4xx_hal_uart_ex.c
  group Middlewares/FreeRTOS
    ../../../../../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../../../../../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2/: cmsis_os2.c
    ../../../../../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../../../../../Middlewares/Third_Party/FreeRTOS/Source/portable/IAR/ARM_CM4F/: port.c portasm.s
  group Middlewares/lib_gnss/Data Exchange/lib_gnss/LibGNSS
    ../../../../../Middlewares/ST/lib_gnss/LibGNSS/Src/: gnss_parser.c gnss_data.c
  group Middlewares/lib_gnss/Data Exchange/lib_gnss/LibNMEA
    ../../../../../Middlewares/ST/lib_gnss/LibNMEA/Src/: NMEA_parser.c
