# IAR project SimOSGetPos.ewp, settings and files
configuration SimOSGetPos (ARM, debug)
  General.OGChipSelectEditMenu: STM32L073RZ ST STM32L073RZ
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32L073xx
  ICCARM.CCIncludePath2: ../Inc; ../../../../../Drivers/STM32L0xx_HAL_Driver/Inc; ../../../../../Drivers/STM32L0xx_HAL_Driver/Inc/Legacy; ../../../../../Drivers/CMSIS/Device/ST/STM32L0xx/Include; ../../../../../Drivers/CMSIS/Include; ../../../../../Middlewares/ST/lib_gnss/LibGNSS/Inc; ../../../../../Middlewares/ST/lib_gnss/LibNMEA/Inc; ../../../../../Drivers/BSP/Components/teseo_liv3f; ../../../../../Drivers/BSP/GNSS1A1
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: SimOSGetPos.hex
  ILINK.IlinkOutputFile: SimOSGetPos.out
  ILINK.IlinkIcfFile: stm32l073xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ./: startup_stm32l073xx.s
  group Application/User
    ../Src/: main.c stm32_bus_ex.c gnss_lib_config.c app_gnss.c stm32l0xx_nucleo_bus.c stm32l0xx_nucleo.c stm32l0xx_it.c stm32l0xx_hal_msp.c
  group Drivers/BSP/Components
    ../../../../../Drivers/BSP/Components/teseo_liv3f/: teseo_liv3f.c teseo_liv3f_i2c.c teseo_liv3f_queue.c teseo_liv3f_uart.c
  group Drivers/BSP/GNSS1A1
    ../../../../../Drivers/BSP/GNSS1A1/: gnss1a1_gnss.c
  group Drivers/CMSIS
    ../Src/: system_stm32l0xx.c
  group Drivers/STM32L0xx_HAL_Driver
    ../../../../../Drivers/STM32L0xx_HAL_Driver/Src/: stm32l0xx_hal_i2c.c stm32l0xx_hal_i2c_ex.c stm32l0xx_hal.c stm32l0xx_hal_rcc.c stm32l0xx_hal_rcc_ex.c stm32l0xx_hal_flash_ramfunc.c stm32l0xx_hal_flash.c stm32l0xx_hal_flash_ex.c stm32l0xx_hal_gpio.c stm32l0xx_hal_dma.c stm32l0xx_hal_pwr.c stm32l0xx_hal_pwr_ex.c stm32l0xx_hal_cortex.c stm32l0xx_hal_exti.c stm32l0xx_hal_uart.c stm32l0xx_hal_uart_ex.c
  group Middlewares/lib_gnss/Data Exchange/lib_gnss/LibGNSS
    ../../../../../Middlewares/ST/lib_gnss/LibGNSS/Src/: gnss_parser.c gnss_data.c
  group Middlewares/lib_gnss/Data Exchange/lib_gnss/LibNMEA
    ../../../../../Middlewares/ST/lib_gnss/LibNMEA/Src/: NMEA_parser.c
