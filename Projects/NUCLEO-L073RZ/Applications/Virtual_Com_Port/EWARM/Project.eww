<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\Virtual_Com_Port.ewp</path>
  </project>
  <batchBuild />
</workspace>
