# IAR project SimOSGetPos.ewp, settings and files
configuration SimOSGetPos (ARM, debug)
  General.OGChipSelectEditMenu: STM32U575ZI ST STM32U575ZI
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 61
  General.FPU2: 6
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32U575xx
  ICCARM.CCIncludePath2: ../Inc; ../../../../../Drivers/STM32U5xx_HAL_Driver/Inc; ../../../../../Drivers/STM32U5xx_HAL_Driver/Inc/Legacy; ../../../../../Drivers/CMSIS/Device/ST/STM32U5xx/Include; ../../../../../Drivers/CMSIS/Include; ../../../../../Middlewares/ST/lib_gnss/LibGNSS/Inc; ../../../../../Middlewares/ST/lib_gnss/LibNMEA/Inc; ../../../../../Drivers/BSP/Components/teseo_liv3f; ../../../../../Drivers/BSP/GNSS1A1
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: SimOSGetPos.hex
  ILINK.IlinkOutputFile: SimOSGetPos.out
  ILINK.IlinkIcfFile: stm32u575xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ./: startup_stm32u575xx.s
  group Application/User
    ../Src/: main.c stm32_bus_ex.c gnss_lib_config.c app_gnss.c stm32u5xx_nucleo_bus.c stm32u5xx_nucleo.c stm32u5xx_it.c stm32u5xx_hal_msp.c stm32u5xx_hal_timebase_tim.c
  group Drivers/BSP/Components
    ../../../../../Drivers/BSP/Components/teseo_liv3f/: teseo_liv3f.c teseo_liv3f_i2c.c teseo_liv3f_queue.c teseo_liv3f_uart.c
  group Drivers/BSP/GNSS1A1
    ../../../../../Drivers/BSP/GNSS1A1/: gnss1a1_gnss.c
  group Drivers/CMSIS
    ../Src/: system_stm32u5xx.c
  group Drivers/STM32U5xx_HAL_Driver
    ../../../../../Drivers/STM32U5xx_HAL_Driver/Src/: stm32u5xx_hal_tim.c stm32u5xx_hal_tim_ex.c stm32u5xx_hal_i2c.c stm32u5xx_hal_i2c_ex.c stm32u5xx_hal_dma.c stm32u5xx_hal_dma_ex.c stm32u5xx_hal.c stm32u5xx_hal_rcc.c stm32u5xx_hal_rcc_ex.c stm32u5xx_hal_cortex.c stm32u5xx_hal_flash.c stm32u5xx_hal_flash_ex.c stm32u5xx_hal_gpio.c stm32u5xx_hal_exti.c stm32u5xx_hal_pwr.c stm32u5xx_hal_pwr_ex.c stm32u5xx_hal_gtzc.c stm32u5xx_hal_icache.c stm32u5xx_hal_uart.c stm32u5xx_hal_uart_ex.c
  group Middlewares/lib_gnss/Data Exchange/lib_gnss/LibGNSS
    ../../../../../Middlewares/ST/lib_gnss/LibGNSS/Src/: gnss_parser.c gnss_data.c
  group Middlewares/lib_gnss/Data Exchange/lib_gnss/LibNMEA
    ../../../../../Middlewares/ST/lib_gnss/LibNMEA/Src/: NMEA_parser.c
